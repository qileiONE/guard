# Keil uVision project BleControl.uvprojx, settings and files
target BLEControl (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BleControl +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\App;..\Driver;..\Stm32FWL\inc;..\startup\syscfg;..\Stm32FWL\CM3;..\Ethernet\Internet;..\Ethernet\W5500;..\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../startup/: startup_stm32f10x_md.s
  group Stm32FWL
    ../Stm32FWL/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_dbgmcu.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_adc.c
    ../Stm32FWL/CM3/: core_cm3.c
    ../startup/syscfg/: system_stm32f10x.c
  group Driver
    ../Driver/: Crc16.c tool.c bsp_init.c uartdeal.c SetupTimer.c eeprom.c rtc.c IIC.c 30205.c delay.c RN5T618.c i2cDrv.c adc.c
  group APP
    ../App/: includes.h GlobeRam.c main.c stm32f10x_it.c AppRunCtr.c Ble.c
  group oled
    ../OLED/: oled.c oled.h
